Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Номер проекта
Time: 2017-10-16T21:52:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 16 21:52:23 2017 * Host: DESKTOP-9RIKPKU * Database: C:\Users\voins\AppData\Local\Temp\{958C5143-45D3-4C85-8784-8E206C2266E7}\ifc * Database version: 5507 * Database creation date: Mon Oct 16 21:52:16 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 16 21:52:17 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 16 21:52:17 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 41, 59, 999999; RefElevation: 0 mm
Прочее - Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Категория: Сведения о проекте; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Прочее - Категория: Сведения о проекте; Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Верхний брус 8 мм; Семейство: Уровень: Верхний брус 8 мм; Семейство и типоразмер: Уровень: Верхний брус 8 мм; Тип: Уровень: Верхний брус 8 мм
Идентификация - Имя типа: Верхний брус 8 мм; Имя: Уровень 1; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: Заголовок уровня - Окружность: Заголовок уровня - Окружность; Образец линий: Центр; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: no; Цвет: 0

# IfcFlowController: Распределитель тепла "Пульсар", Распределитель тепла:Распределитель тепла "Пульсар":264146
In: Уровень 1
Type - Material: Стекло, Пластмасса, непрозрачная, белая, Пластмасса, непрозрачная, черная
Type - Идентификация - Имя типа: Распределитель тепла "Пульсар"
Type - Материалы и отделка - Корпус. Белый пластик: Пластмасса, непрозрачная, белая; Текст на циферблате: Пластмасса, непрозрачная, черная; Циферблат. Стекло: Стекло
Type - Прочее - Категория: Арматура трубопроводов; Имя семейства: Распределитель тепла
Type - Текст - URL страницы изделия: http://teplovodokhran.ru/products/raspredelitel-tepla-pulsar-radiatornyy-raspredelitel.html; Единица измерения: шт.; Завод-изготовитель: ООО НПП Тепловодохран; Код изделия: Н00002535; Масса_Текст (кг): 0,1; Наименование: УСТРОЙСТВО ДЛЯ РАСПРЕДЕЛЕНИЯ ТЕПЛОВОЙ ЭНЕРГИИ «ПУЛЬСАР»; Обозначение: ЮТЛИ.408842.040 РЭ
Pset_DistributionFlowElementCommon - Reference: Распределитель тепла "Пульсар"
Зависимости - Длина: 1400 mm; Рабочая плоскость: Уровень : Уровень 1; Смещение: 0 mm
Идентификация - Маркировка: 1
Изоляционный слой - Толщина изоляции: 0 mm
Прочее - Код типа: Распределитель тепла: Распределитель тепла "Пульсар"; Семейство: Распределитель тепла: Распределитель тепла "Пульсар"; Семейство и типоразмер: Распределитель тепла: Распределитель тепла "Пульсар"; Тип: Распределитель тепла: Распределитель тепла "Пульсар"
Размеры - Объем: 0.0000845973 m3; Площадь: 0.00718939 m2
Стадии - Стадия возведения: Новая конструкция
